# Keil uVision project LED_Blink.uvprojx, settings and files
target Blink_LED_F4 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_Blink
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, USE_STM324xG_EVAL
  c include: .\src;.\startup;..\Materials\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Include;..\Materials\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Materials\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\Materials\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Utilities\STM32_EVAL\Common;..\Materials\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Materials\STM32F4xx_DSP_StdPeriph_Lib_V1.9.0\Libraries\STM32F4xx_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: main.c main.h readme.txt stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group startup
    ./startup/: startup_stm32f40xx.s
  group libs
    ../Materials/STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
